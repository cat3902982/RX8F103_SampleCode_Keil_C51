# Keil uVision project CustomInfor_Operation.uvproj, settings and files
target CustomInfor_Operation (MCS-51)
  device: R80515 Cadence Design Systems Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MODC2 MDU_R515
  output: CustomInfor_Operation +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  link misc: REMOVEUNUSED
  group APP
    ./Code/: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group Startup
    ../../Startup/: STARTUP.A51
