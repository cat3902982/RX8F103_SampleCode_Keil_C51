# Keil uVision project ADC_Measure_Interrupt.uvproj, settings and files
target ADC_Measure_Interrupt (MCS-51)
  device: R80515 Cadence Design Systems Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MODC2 MDU_R515
  output: ADC_Vref_Out +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  link misc: REMOVEUNUSED
  group APP
    ./Code/: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group Startup
    ../../Startup/: STARTUP.A51
